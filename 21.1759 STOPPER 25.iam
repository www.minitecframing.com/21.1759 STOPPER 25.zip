# Autodesk Inventor assembly: 21.1759 STOPPER 25
## iProperties
Created: 2007-03
Part Number: 21.1759 STOPPER 25
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
